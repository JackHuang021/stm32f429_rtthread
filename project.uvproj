# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F429xx
  c include: applications;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include;rt-thread\components\net\lwip-2.0.3\src;rt-thread\components\net\lwip-2.0.3\src\include;rt-thread\components\net\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip-2.0.3\src\arch\include;rt-thread\components\net\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip-2.0.3\src\include\posix;rt-thread\components\libc\posix\io\poll
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: dataqueue.c pipe.c workqueue.c waitqueue.c ringblk_buf.c ringbuffer.c completion.c
  group Drivers
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: spi_flash_init.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_sdram.c drv_soft_i2c.c drv_usart.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: timer.c scheduler.c irq.c mempool.c ipc.c thread.c kservice.c idle.c components.c memheap.c device.c clock.c object.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    rt-thread/components/net/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.3/src/arch/: sys_arch.c
