# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F429xx
  c include: applications;.;rt-thread\components\cplusplus;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;packages\gt911-latest\inc;.;rt-thread\include;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include;rt-thread\components\net\lwip-2.0.3\src;rt-thread\components\net\lwip-2.0.3\src\include;rt-thread\components\net\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip-2.0.3\src\arch\include;rt-thread\components\net\lwip-2.0.3\src\include\netif;packages\netutils-v1.3.1\ntp;rt-thread\components\libc\posix\io;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\socket\sys_socket;packages\touchgfx2rtt-latest\TouchGFX\App;packages\touchgfx2rtt-latest\TouchGFX\target;packages\touchgfx2rtt-latest\TouchGFX\target\generated;packages\touchgfx2rtt-latest\Middlewares\ST\touchgfx\framework\include;packages\touchgfx2rtt-latest\TouchGFX\generated\fonts\include;packages\touchgfx2rtt-latest\TouchGFX\generated\gui_generated\include;packages\touchgfx2rtt-latest\TouchGFX\generated\images\include;packages\touchgfx2rtt-latest\TouchGFX\generated\texts\include;packages\touchgfx2rtt-latest\TouchGFX\gui\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./packages/gt911-latest/samples/: gt911_sample.c
  group CPlusPlus
    rt-thread/components/cplusplus/: cxx_crt_init.c cxx_crt.cpp cxx_Semaphore.cpp cxx_Thread.cpp cxx_Mutex.cpp
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: dataqueue.c ringbuffer.c pipe.c workqueue.c waitqueue.c completion.c ringblk_buf.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/ports/: phy_reset.c spi_flash_init.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_sdram.c drv_rtc.c drv_soft_i2c.c drv_eth.c drv_sdio.c drv_lcd.c drv_usart.c drv_common.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group gt911
    packages/gt911-latest/src/: gt911.c
  group Kernel
    rt-thread/src/: components.c timer.c mempool.c ipc.c scheduler.c kservice.c object.c memheap.c thread.c irq.c clock.c idle.c device.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    rt-thread/components/net/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.3/src/arch/: sys_arch.c
  group NetUtils
    packages/netutils-v1.3.1/ntp/: ntp.c
  group POSIX
    rt-thread/components/libc/posix/io/: select.c
    rt-thread/components/libc/posix/io/poll/: poll.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
  group TouchGFX_app
    packages/touchgfx2rtt-latest/TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
    packages/touchgfx2rtt-latest/TouchGFX/target/generated/: STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp OSWrappers_RTT.cpp
    packages/touchgfx2rtt-latest/Middlewares/ST/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
    packages/touchgfx2rtt-latest/examples/: touchgfx_main.c
    packages/touchgfx2rtt-latest/TouchGFX/App/: app_touchgfx.c
  group TouchGFX_generated
    packages/touchgfx2rtt-latest/TouchGFX/generated/fonts/src/: Font_SourceCodePro_Regular_16_4bpp_0.cpp Kerning_SourceSansPro_Bold_128_4bpp.cpp Table_SourceSansPro_Bold_128_4bpp.cpp CachedFont.cpp Table_SourceSansPro_Bold_30_4bpp.cpp UnmappedDataFont.cpp Kerning_SourceCodePro_Regular_10_4bpp.cpp Font_SourceCodePro_Regular_10_4bpp_0.cpp ApplicationFontProvider.cpp Font_SourceSansPro_Bold_30_4bpp_0.cpp Font_SourceSansPro_Bold_128_4bpp_0.cpp GeneratedFont.cpp Table_SourceCodePro_Regular_10_4bpp.cpp Table_SourceCodePro_Regular_16_4bpp.cpp FontCache.cpp Kerning_SourceSansPro_Bold_30_4bpp.cpp Kerning_SourceCodePro_Regular_16_4bpp.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/introduction_screen/: IntroductionViewBase.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/images/src/: image_arrow_left.cpp image_dark_button.cpp BitmapDatabase.cpp image_logo.cpp image_dark_button_pressed.cpp image_arrow_right.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/texts/src/: Texts.cpp TypedTextDatabase.cpp LanguageGb.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/containers/: LabelBoxBase.cpp
    packages/touchgfx2rtt-latest/TouchGFX/generated/gui_generated/src/demo_screen/: DemoViewBase.cpp
  group TouchGFX_gui
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/common/: FrontendApplication.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/demo_screen/: DemoPresenter.cpp DemoView.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/containers/: LabelBox.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/introduction_screen/: IntroductionPresenter.cpp IntroductionView.cpp
    packages/touchgfx2rtt-latest/TouchGFX/gui/src/model/: FakeHardware.cpp Model.cpp
