# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\lwip-2.0.3\src\include\netif; rt-thread\include; rt-thread\components\finsh; board\CubeMX_Config\Inc; rt-thread\components\net\lwip-2.0.3\src; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\libcpu\arm\common; .; rt-thread\components\libc\compilers\common\nogcc; rt-thread\components\drivers\include; board; rt-thread\components\net\lwip-2.0.3\src\include\ipv4; rt-thread\components\net\lwip-2.0.3\src\arch\include; libraries\STM32F4xx_HAL\CMSIS\Include; board\ports; rt-thread\components\net\lwip-2.0.3\src\include\posix; rt-thread\libcpu\arm\cortex-m4; applications; libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\libc\posix\io\poll; rt-thread\components\drivers\spi; libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; rt-thread\components\libc\compilers\common; rt-thread\components\net\lwip-2.0.3\src\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: ringbuffer.c workqueue.c pipe.c completion.c waitqueue.c ringblk_buf.c dataqueue.c
  group Drivers
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: spi_flash_init.c
    libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_sdram.c drv_soft_i2c.c drv_usart.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: clock.c device.c mempool.c memheap.c ipc.c thread.c components.c object.c timer.c irq.c idle.c kservice.c scheduler.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    rt-thread/components/net/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.3/src/arch/: sys_arch.c
